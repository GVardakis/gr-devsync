<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>long_seq</value></param>
<param><key>comment</key><value>The IEEE 802.11 long
 training sequence</value></param>
<param><key>value</key><value>[ 0.1562 - 0.0j    , -0.0051 + 0.1203j, 0.0397 + 0.1112j, 0.0968 - 0.0828j,
     0.0211 - 0.0279j, 0.0598 + 0.0877j, -0.1151 + 0.0552j, -0.0383 + 0.1062j,
     0.0975 + 0.0259j, 0.0533 - 0.0041j, 0.0010 + 0.115j , -0.1368 + 0.0474j,
     0.0245 + 0.0585j, 0.0587 + 0.0149j, -0.0225 - 0.1607j, 0.1192 + 0.0041j,
     0.0625 + 0.0625j, 0.0369 - 0.0983j, -0.0572 - 0.0393j, -0.1313 - 0.0652j,
     0.0822 - 0.0924j, 0.0696 - 0.0141j, -0.0603 - 0.0813j, -0.0565 + 0.0218j,
     - 0.0350 + 0.1509j, -0.1219 + 0.0166j, -0.1273 + 0.0205j, 0.0751 + 0.074j ,
     - 0.0028 - 0.0538j, -0.0919 - 0.1151j, 0.0917 - 0.1059j, 0.0123 - 0.0976j,
     - 0.1562 - 0.0j    , 0.0123 + 0.0976j, 0.0917 + 0.1059j, -0.0919 + 0.1151j,
     - 0.0028 + 0.0538j, 0.0751 - 0.074j , -0.1273 - 0.0205j, -0.1219 - 0.0166j,
     - 0.0350 - 0.1509j, -0.0565 - 0.0218j, -0.0603 + 0.0813j, 0.0696 + 0.0141j,
     0.0822 + 0.0924j, -0.1313 + 0.0652j, -0.0572 + 0.0393j, 0.0369 + 0.0983j,
     0.0625 - 0.0625j, 0.1192 - 0.0041j, -0.0225 + 0.1607j, 0.0587 - 0.0149j,
     0.0245 - 0.0585j, -0.1368 - 0.0474j, 0.0010 - 0.115j , 0.0533 + 0.0041j,
     0.0975 - 0.0259j, -0.0383 - 0.1062j, -0.1151 - 0.0552j, 0.0598 - 0.0877j,
     0.0211 + 0.0279j, 0.0968 + 0.0828j, 0.0397 - 0.1112j, -0.0051 - 0.1203j] + 1000*[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_elements</value></param>
<param><key>comment</key><value>Normalization 
window</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_streams</value></param>
<param><key>comment</key><value>Total number of
 receiving channels</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>comment</key><value>Replace this block with the sink of the TX SDR</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>num_streams</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>comment</key><value>Replace this block
with the source block
of the RX SDRs</value></param>
<param><key>num_outputs</key><value>num_streams</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_3_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>comment</key><value>Use this block for transmission</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>numpy.conj(long_seq) </value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>num_elements</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>num_elements</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>num_elements</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>num_elements</value></param>
</block>
<block>
<key>devsync_alligner</key>
<param><key>id</key><value>devsync_alligner_0</value></param>
<param><key>comment</key><value>The alligner takes as input
the message from the peak detector
as well as the input from the source
SDR block. The outputs are the alligned 
streams after the long training sequence
detection</value></param>
<param><key>num_streams</key><value>num_streams</value></param>
</block>
<block>
<key>devsync_peak_detector</key>
<param><key>id</key><value>devsync_peak_detector_0</value></param>
<param><key>disc_samp</key><value>100</value></param>
<param><key>inf</key><value>0</value></param>
<param><key>num_streams</key><value>num_streams</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>win</key><value>100</value></param>
</block>
<block>
<key>devsync_rms_normalization</key>
<param><key>id</key><value>devsync_rms_normalization_0</value></param>
<param><key>num_streams</key><value>num_streams</value></param>
<param><key>vlen</key><value>num_elements</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_4</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>long_seq[::-1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_4_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>long_seq[::-1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_4_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>long_seq[::-1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_4_0_0_0</value></param>
<param><key>comment</key><value>The FFT filter blocks
perform the 
crosscorrelation</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>long_seq[::-1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>devsync_alligner_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>devsync_alligner_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_4_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>devsync_alligner_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_4_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>devsync_alligner_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_4_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>devsync_rms_normalization_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0_0_0</source_block_id><sink_block_id>devsync_rms_normalization_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0_1</source_block_id><sink_block_id>devsync_rms_normalization_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_3_1</source_block_id><sink_block_id>devsync_rms_normalization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>devsync_peak_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1_0</source_block_id><sink_block_id>devsync_peak_detector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1_1</source_block_id><sink_block_id>devsync_peak_detector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1_2</source_block_id><sink_block_id>devsync_peak_detector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>devsync_alligner_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>devsync_alligner_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>devsync_alligner_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>devsync_alligner_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>devsync_peak_detector_0</source_block_id><sink_block_id>devsync_alligner_0</sink_block_id><source_key>shifts_out</source_key><sink_key>phase_init</sink_key></connection>
<connection><source_block_id>devsync_rms_normalization_0</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>devsync_rms_normalization_0</source_block_id><sink_block_id>blocks_vector_to_stream_1_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>devsync_rms_normalization_0</source_block_id><sink_block_id>blocks_vector_to_stream_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>devsync_rms_normalization_0</source_block_id><sink_block_id>blocks_vector_to_stream_1_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_4</source_block_id><sink_block_id>blocks_stream_to_vector_0_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_4_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_4_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_4_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
